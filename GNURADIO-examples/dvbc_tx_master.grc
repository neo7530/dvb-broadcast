<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dvbc_tx_WXGUI</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>anz0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>str(center_freq/1000000)+"MHZ / "+mode+" / "+str(symrate/1000)+" kSym/s"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Parameter</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>config_file</key><value>./dvbc.conf</value></param>
<param><key>value</key><value>802000000</value></param>
<param><key>option</key><value>freqency</value></param>
<param><key>section</key><value>hackrf</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>config_file</key><value>./dvbc.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>if-gain</value></param>
<param><key>section</key><value>hackrf</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>mode</value></param>
<param><key>config_file</key><value>./dvbc.conf</value></param>
<param><key>value</key><value>128QAM</value></param>
<param><key>option</key><value>mode</value></param>
<param><key>section</key><value>dvbc</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>config_file</key><value>./dvbc.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>rf-gain</value></param>
<param><key>section</key><value>hackrf</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>symrate * 2</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>symrate</value></param>
<param><key>config_file</key><value>./dvbc.conf</value></param>
<param><key>value</key><value>6900000</value></param>
<param><key>option</key><value>symbolrate</value></param>
<param><key>section</key><value>dvbc</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/marco/DVB/10.5MPEG.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>dtv_dvbt_convolutional_interleaver</key>
<param><key>id</key><value>dtv_dvbt_convolutional_interleaver_0</value></param>
<param><key>blocks</key><value>136</value></param>
<param><key>M</key><value>17</value></param>
<param><key>I</key><value>12</value></param>
</block>
<block>
<key>dtv_dvbt_energy_dispersal</key>
<param><key>id</key><value>dtv_dvbt_energy_dispersal_0</value></param>
<param><key>nsize</key><value>1</value></param>
</block>
<block>
<key>dtv_dvbt_reed_solomon_enc</key>
<param><key>id</key><value>dtv_dvbt_reed_solomon_enc_0</value></param>
<param><key>blocks</key><value>8</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>k</key><value>239</value></param>
<param><key>n</key><value>255</value></param>
<param><key>s</key><value>51</value></param>
<param><key>m</key><value>8</value></param>
<param><key>p</key><value>2</value></param>
<param><key>t</key><value>8</value></param>
</block>
<block>
<key>dvbc_modulator_bc</key>
<param><key>id</key><value>dvbc_modulator_bc_0</value></param>
<param><key>constellation</key><value>MOD_64QAM</value></param>
</block>
<block>
<key>dvbc_symbolmapper_bb</key>
<param><key>id</key><value>dvbc_symbolmapper_bb_0</value></param>
<param><key>constellation</key><value>MOD_64QAM</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.root_raised_cosine(0.85, samp_rate, samp_rate/2, 0.15, rrc_taps)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_1</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>bw0</key><value>8750000</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value>buffers=128,buflen=32768</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>size</key><value>4096</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>4</value></param>
<param><key>xmin</key><value>-4</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>center_freq</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>dtv_dvbt_energy_dispersal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_convolutional_interleaver_0</source_block_id><sink_block_id>dvbc_symbolmapper_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_energy_dispersal_0</source_block_id><sink_block_id>dtv_dvbt_reed_solomon_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_reed_solomon_enc_0</source_block_id><sink_block_id>dtv_dvbt_convolutional_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbc_modulator_bc_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbc_modulator_bc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbc_symbolmapper_bb_0</source_block_id><sink_block_id>dvbc_modulator_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>osmosdr_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
