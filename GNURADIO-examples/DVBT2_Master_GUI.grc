<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>DVBT2_Master</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>CARREXT</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>ext-carriers</value></param>
<param><key>section</key><value>dvbt2</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>CODERATE</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>coderate</value></param>
<param><key>section</key><value>dvbt2</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>CONSTELLATION</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>constellation</value></param>
<param><key>section</key><value>dvbt2</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>DATASYM</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>datasymbols</value></param>
<param><key>section</key><value>dvbt2</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>FECBLKS</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>fec-blocks</value></param>
<param><key>section</key><value>dvbt2</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>FFTSIZE</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>fft-size</value></param>
<param><key>section</key><value>dvbt2</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>GI</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>guard-interval</value></param>
<param><key>section</key><value>dvbt2</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>L1MOD</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>L1-mod</value></param>
<param><key>section</key><value>dvbt2</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>PAPR</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>papr</value></param>
<param><key>section</key><value>dvbt2</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>PILOT</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>pilot-pattern</value></param>
<param><key>section</key><value>dvbt2</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>PREAMBLE</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>preamble</value></param>
<param><key>section</key><value>dvbt2</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>VERSION</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>version</value></param>
<param><key>section</key><value>dvbt2</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>band_width</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>bandwidth</value></param>
<param><key>section</key><value>hackrf</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>frequency</value></param>
<param><key>section</key><value>hackrf</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>if-gain</value></param>
<param><key>section</key><value>hackrf</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>config_file</key><value>./dvbt2.conf</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>rf-gain</value></param>
<param><key>section</key><value>hackrf</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>(8000000.0 * 8) / 7</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>vv.cfile</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/marco/DVB-T2/out.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_len</key><value>(16384 * 19) / 128</value></param>
<param><key>input_size</key><value>16384</value></param>
<param><key>tagname</key><value></value></param>
</block>
<block>
<key>dtv_dvb_bbheader_bb</key>
<param><key>id</key><value>dtv_dvb_bbheader_bb_0</value></param>
<param><key>mode</key><value>INPUTMODE_HIEFF</value></param>
<param><key>rate1</key><value>C1_2</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>inband</key><value>INBAND_OFF</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvb_bbscrambler_bb</key>
<param><key>id</key><value>dtv_dvb_bbscrambler_bb_0</value></param>
<param><key>rate1</key><value>C1_2</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvb_bch_bb</key>
<param><key>id</key><value>dtv_dvb_bch_bb_0</value></param>
<param><key>rate1</key><value>C1_2</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvb_ldpc_bb</key>
<param><key>id</key><value>dtv_dvb_ldpc_bb_0</value></param>
<param><key>rate1</key><value>C1_2</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvbt2_cellinterleaver_cc</key>
<param><key>id</key><value>dtv_dvbt2_cellinterleaver_cc_0</value></param>
<param><key>constellation</key><value>MOD_64QAM</value></param>
<param><key>fecblocks</key><value>139</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>tiblocks</key><value>3</value></param>
</block>
<block>
<key>dtv_dvbt2_framemapper_cc</key>
<param><key>id</key><value>dtv_dvbt2_framemapper_cc_0</value></param>
<param><key>inputmode</key><value>FECFRAME_NORMAL</value></param>
<param><key>rate</key><value>C1_2</value></param>
<param><key>rotation</key><value>ROTATION_OFF</value></param>
<param><key>constellation</key><value>MOD_64QAM</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fecblocks</key><value>139</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>fftsize1</key><value>FFTSIZE_16K</value></param>
<param><key>guardinterval</key><value>GI_19_128</value></param>
<param><key>l1constellation</key><value>L1_MOD_BPSK</value></param>
<param><key>numdatasyms</key><value>118</value></param>
<param><key>paprmode1</key><value>PAPR_OFF</value></param>
<param><key>pilotpattern</key><value>PILOT_PP2</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>version</key><value>VERSION_111</value></param>
<param><key>t2frames</key><value>2</value></param>
<param><key>tiblocks</key><value>3</value></param>
</block>
<block>
<key>dtv_dvbt2_freqinterleaver_cc</key>
<param><key>id</key><value>dtv_dvbt2_freqinterleaver_cc_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_16K</value></param>
<param><key>guardinterval</key><value>GI_19_128</value></param>
<param><key>numdatasyms</key><value>118</value></param>
<param><key>paprmode1</key><value>PAPR_OFF</value></param>
<param><key>pilotpattern</key><value>PILOT_PP2</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>version</key><value>VERSION_111</value></param>
</block>
<block>
<key>dtv_dvbt2_interleaver_bb</key>
<param><key>id</key><value>dtv_dvbt2_interleaver_bb_0</value></param>
<param><key>rate</key><value>C1_2</value></param>
<param><key>constellation</key><value>MOD_64QAM</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
</block>
<block>
<key>dtv_dvbt2_modulator_bc</key>
<param><key>id</key><value>dtv_dvbt2_modulator_bc_0</value></param>
<param><key>rotation</key><value>ROTATION_OFF</value></param>
<param><key>constellation</key><value>MOD_64QAM</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
</block>
<block>
<key>dtv_dvbt2_p1insertion_cc</key>
<param><key>id</key><value>dtv_dvbt2_p1insertion_cc_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize1</key><value>FFTSIZE_16K</value></param>
<param><key>guardinterval</key><value>GI_19_128</value></param>
<param><key>numdatasyms</key><value>118</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>showlevels</key><value>SHOWLEVELS_OFF</value></param>
<param><key>version</key><value>VERSION_111</value></param>
</block>
<block>
<key>dtv_dvbt2_pilotgenerator_cc</key>
<param><key>id</key><value>dtv_dvbt2_pilotgenerator_cc_0</value></param>
<param><key>bandwidth</key><value>BANDWIDTH_8_0_MHZ</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_16K</value></param>
<param><key>guardinterval</key><value>GI_19_128</value></param>
<param><key>numdatasyms</key><value>118</value></param>
<param><key>paprmode1</key><value>PAPR_OFF</value></param>
<param><key>pilotpattern</key><value>PILOT_PP2</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>equalization</key><value>EQUALIZATION_OFF</value></param>
<param><key>version</key><value>VERSION_111</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>bw0</key><value>band_width</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value>hackrf,buffers=128,buflen=32768</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>dtv_dvb_bbheader_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>dtv_dvbt2_p1insertion_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bbheader_bb_0</source_block_id><sink_block_id>dtv_dvb_bbscrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bbscrambler_bb_0</source_block_id><sink_block_id>dtv_dvb_bch_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bch_bb_0</source_block_id><sink_block_id>dtv_dvb_ldpc_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_ldpc_bb_0</source_block_id><sink_block_id>dtv_dvbt2_interleaver_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_cellinterleaver_cc_0</source_block_id><sink_block_id>dtv_dvbt2_framemapper_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_framemapper_cc_0</source_block_id><sink_block_id>dtv_dvbt2_freqinterleaver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_freqinterleaver_cc_0</source_block_id><sink_block_id>dtv_dvbt2_pilotgenerator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_interleaver_bb_0</source_block_id><sink_block_id>dtv_dvbt2_modulator_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_modulator_bc_0</source_block_id><sink_block_id>dtv_dvbt2_cellinterleaver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_p1insertion_cc_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_p1insertion_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_pilotgenerator_cc_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
